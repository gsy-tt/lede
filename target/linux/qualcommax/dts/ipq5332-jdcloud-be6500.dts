#include "qcom-ipq5332.dtsi"
#include <dt-bindings/clock/qcom,gcc-ipq5332.h>
#include <dt-bindings/gpio/gpio.h>
#include <dt-bindings/usb/otg.h>

/ {
    model = "JDCloud BE6500 (IPQ5332)";
    compatible = "jdcloud,be6500", "qcom,ipq5332";

    memory@80000000 {
        device_type = "memory";  # 补充 device_type 属性（标准要求）
        reg = <0x80000000 0x40000000>;  # 格式：<起始地址 大小>（0x40000000 = 1GB）
    };

    chosen {
        bootargs = "console=ttyMSM0,115200n8 earlycon=msm_geni_serial,0x0a000000";
    };
};

/* 以太网控制器配置 */
&ethernet {
    compatible = "qcom,ipq5332-ethernet";
    status = "okay";
    qcom,mdio-delay = <100>;

    mdio {
        compatible = "snps,dwmac-mdio";
        #address-cells = <1>;
        #size-cells = <0>;

        /* QCA8386 交换机 (4口全千兆) */
        mdio@a9000000 {  # MDIO控制器地址
            qca8386: switch@0 {
                compatible = "qca,qca8386";
                reg = <0x0>;
                qca,ports = <4>;  # 4个2.5G网口
            };
        };
    };

    ports {
        #address-cells = <1>;
        #size-cells = <0>;

        /* WAN 口 (连接到交换机端口0) */
        port@0 {
            reg = <0>;
            label = "wan";
            phy-handle = <&qca8386_port0>;
            qcom,phy-mode = "rgmii";
        };

        /* LAN 口 (连接到交换机端口1-3) */
        port@1 { reg = <1>; label = "lan1"; phy-handle = <&qca8386_port1>; qcom,phy-mode = "rgmii"; };
        port@2 { reg = <2>; label = "lan2"; phy-handle = <&qca8386_port2>; qcom,phy-mode = "rgmii"; };
        port@3 { reg = <3>; label = "lan3"; phy-handle = <&qca8386_port3>; qcom,phy-mode = "rgmii"; };
    };
};

/* 引用 QCA8386 交换机端口 */
&qca8386@0 {
    qca8386_port0: port@0 { reg = <0>; };
    qca8386_port1: port@1 { reg = <1>; };
    qca8386_port2: port@2 { reg = <2>; };
    qca8386_port3: port@3 { reg = <3>; };
};

/* USB 3.0 控制器配置 */
&usb3 {
    status = "okay";
    dr_mode = "host";  /* 主机模式 */
    
    /* USB 供电控制 (如果有 GPIO 控制供电) */
    vbus-supply = <&reg_usb_vbus>;
    qcom,usb3-phy-cal = <1>;  /* 启用 PHY 校准 */
    
    /* 端口配置 */
    usb3-port@0 {
        reg = <0>;
        status = "okay";
        usb-role = "host";
        disable-over-current;  /* 如果没有过流检测 */
    };
};

/* USB 3.0 供电调节器 (如果有 GPIO 控制) */
reg_usb_vbus: regulator@0 {
    compatible = "regulator-fixed";
    regulator-name = "vbus";
    regulator-min-microvolt = <5000000>;
    regulator-max-microvolt = <5000000>;
    gpio = <&gpio 12 GPIO_ACTIVE_HIGH>;  // 确认实际控制GPIO引脚号
    enable-active-high;
};

/* 5.2G Wi-Fi 配置（示例：假设为第一个5G模块） */
&wifi0 {
    compatible = "qcom,ath11k";
    status = "okay";
    qcom,ath11k-calibration-variant = "QCN6224-5.2G";  /* 5.2G校准数据变体名 */
    interrupts = <GIC_SPI 123 IRQ_TYPE_LEVEL_HIGH>;  /* 实际中断号 */
    qcom,ssid = "JDCloud-BE6500-5.2G";
    ieee80211-freq-limit = <5170000 5330000>;  /* 5.2G频段范围（5170-5330 MHz） */
};

/* 5.8G Wi-Fi 配置（示例：假设为第二个5G模块） */
&wifi1 {
    compatible = "qcom,ath11k";
    status = "okay";
    qcom,ath11k-calibration-variant = "QCN6224-5.8G";  /* 5.8G校准数据变体名 */
    interrupts = <GIC_SPI 124 IRQ_TYPE_LEVEL_HIGH>;  /* 实际中断号 */
    qcom,ssid = "JDCloud-BE6500-5.8G";
    ieee80211-freq-limit = <5490000 5835000>;  /* 5.8G频段范围（5490-5835 MHz） */
};

/* 2.4G Wi-Fi 配置 */
&wifi2 {
    compatible = "qcom,ath10k";  /* 假设2.4G使用ath10k驱动 */
    status = "okay";
    qcom,ath10k-calibration-variant = "QCN5054";  /* 2.4G校准数据变体名 */
    interrupts = <GIC_SPI 125 IRQ_TYPE_LEVEL_HIGH>;  /* 实际中断号 */
    qcom,ssid = "JDCloud-BE6500-2.4G";
    ieee80211-freq-limit = <2412000 2484000>;  /* 2.4G频段范围（2412-2484 MHz） */
};


gpio-leds {
    qpf4559-pa {
        label = "qpf4559:pa-en";
        gpios = <&gpio 12 GPIO_ACTIVE_HIGH>;  # 假设GPIO12控制5G PA
    };
};

leds {
    compatible = "gpio-leds";
    status_led: status {
        label = "green:status";
        gpios = <&gpio 57 GPIO_ACTIVE_HIGH>;  // 实际GPIO引脚
    };
};

keys {
    compatible = "gpio-keys";
    reset {
        label = "reset";
        gpios = <&gpio 56 GPIO_ACTIVE_LOW>;  // 实际复位键GPIO
        linux,code = <KEY_RESTART>;
    };
};


